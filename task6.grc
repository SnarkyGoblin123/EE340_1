options:
  parameters:
    author: rohannafde
    generate_options: qt_gui
    id: task6
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1.41421, -1+1j, 1.41421*1j, 1+1j, 1.41421, 1-1j, -1.41421*1j, -1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '4'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*20
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*20
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*20
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*20
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '100'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/joel/Documents/EE340/Lab10/task6.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/joel/Documents/EE340/Lab10/Original_Text.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.41421'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.41421'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/8
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.001'
    init: '0'
    low: '-0.001'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0.001'
    init: '0'
    low: '-0.001'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: 5e4
    sensitivity: '-5e4'
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '2.5'
    samp_rate: 5e4
    sensitivity: '-5'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1.41421, -1+1j, 1.41421*1j, 1+1j, 1.41421, 1-1j, -1.41421*1j, -1-1j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: fff
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[-1, 0.99]'
    fftaps: '[1e-2]'
    type: ccf
  states: {}
- name: iir_filter_xxx_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[-1, 1]'
    fftaps: '[1.0001, -1]'
    type: ffd
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    gain: '2'
    interp: '1'
    samp_rate: samp_rate*20
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    gain: '2'
    interp: '1'
    samp_rate: samp_rate*20
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '3'
    interp: '1'
    ntaps: '88'
    samp_rate: samp_rate
    sym_rate: '50000'
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: '88'
    samp_rate: samp_rate
    sym_rate: '50000'
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_1_1
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: '88'
    samp_rate: samp_rate
    sym_rate: '50000'
    type: fir_filter_fff
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_1_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_1_1, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0_0_1, '1']
- [blocks_complex_to_float_0_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_0_1, '1']
- [blocks_complex_to_float_0_0, '1', blocks_threshold_ff_0_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_delay_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_0_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_vco_c_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0_1, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '0']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '1']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '2']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '3']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '4']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '5']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '6']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2, '7']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_2_0, '1']
- [blocks_multiply_xx_0_2, '0', iir_filter_xxx_0, '0']
- [blocks_multiply_xx_2, '0', blocks_delay_0_0, '0']
- [blocks_multiply_xx_2, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_xx_2_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_xx_2_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_sub_xx_0, '0', iir_filter_xxx_1_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_skiphead_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_2_0, '0']
- [blocks_vco_c_0_0, '0', zeromq_push_sink_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_complex_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_float_to_complex_0, '1']
- [iir_filter_xxx_0, '0', blocks_complex_to_float_0_0, '0']
- [iir_filter_xxx_1_0, '0', blocks_vco_c_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', root_raised_cosine_filter_0_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0_0, '0', root_raised_cosine_filter_0_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', root_raised_cosine_filter_0_1_1, '0']
- [root_raised_cosine_filter_0_1, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_1_0, '0', fir_filter_xxx_0, '0']
- [root_raised_cosine_filter_0_1_1, '0', fir_filter_xxx_0_0, '0']
- [zeromq_pull_source_0, '0', blocks_multiply_const_vxx_2, '0']

metadata:
  file_format: 1
